# Keil uVision project NUEDC_2021B.uvprojx, settings and files
target NUEDC_2021B (6240000::V6.24::ARMCLANG)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NUEDC_2021B +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../BSP/Buttons;../BSP/OLED;../BSP/u8g2;../APP/Applications;../APP/framework;../APP/PowerControl;../APP/MiaoUI;../APP/MiaoUI/core;../APP/MiaoUI/display;../APP/MiaoUI/fonts;../APP/MiaoUI/images;../APP/MiaoUI/indev;../APP/MiaoUI/notifications;../APP/MiaoUI/widget
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32g474xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c app_freertos.c adc.c comp.c cordic.c dac.c dma.c fdcan.c fmac.c hrtim.c i2c.c quadspi.c rtc.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c stm32g4xx_hal_timebase_tim.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_gpio.c stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_ll_rcc.c stm32g4xx_ll_pwr.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_comp.c stm32g4xx_ll_cordic.c stm32g4xx_ll_dma.c stm32g4xx_ll_dac.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_fmac.c stm32g4xx_ll_hrtim.c stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal_qspi.c stm32g4xx_hal_rtc.c stm32g4xx_hal_rtc_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_1.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group BSP
    ../BSP/Buttons/: buttons.c
    ../BSP/OLED/: oled.c
  group u8g2
    ../BSP/u8g2/: u8g2_arc.c u8g2_bitmap.c u8g2_box.c u8g2_buffer.c u8g2_button.c u8g2_circle.c u8g2_cleardisplay.c u8g2_d_memory.c u8g2_d_setup.c u8g2_font.c u8g2_fonts.c u8g2_hvline.c u8g2_input_value.c u8g2_intersection.c u8g2_kerning.c u8g2_line.c u8g2_ll_hvline.c u8g2_message.c u8g2_polygon.c u8g2_selection_list.c u8g2_setup.c u8log.c u8log_u8g2.c u8log_u8x8.c u8x8_8x8.c u8x8_byte.c u8x8_cad.c u8x8_capture.c u8x8_d_ssd1306_128x64_noname.c u8x8_debounce.c u8x8_display.c u8x8_fonts.c u8x8_gpio.c u8x8_input_value.c u8x8_message.c u8x8_selection_list.c u8x8_setup.c u8x8_string.c u8x8_u8toa.c u8x8_u16toa.c
  group MiaoUI
    ../APP/MiaoUI/core/: ui.c
    ../APP/MiaoUI/fonts/: fonts.c
    ../APP/MiaoUI/images/: image.c
    ../APP/MiaoUI/widget/: custom.c parameter.c text.c wave.c
    ../APP/MiaoUI/display/: dispDriver.c
    ../APP/MiaoUI/indev/: indevDriver.c
    ../APP/MiaoUI/notifications/: display_effects.c notifications_draw.c
    ../APP/MiaoUI/: ui_conf.c
  group framework
    ../APP/framework/: pm_controller.c pm_device.c pm_device_builtin.c pm_policy.c pm_sleep_timer.c powerdown_task.c system_operation.c system_statistic.c time.c pm_ui_register.c
  group Tasks
    ../APP/: adc_handle.c beep.c button_handle.c ui_task.c
  group Applications
    ../APP/Applications/: burn_in_tester.c game_dinosaur.c game_snake.c i2c_scanner.c
  group PowerControl
    ../APP/PowerControl/: algorithm_control.c algorithm_filtering.c conv_adc.c conv_controller.c conv_loop.c conv_protection.c conv_pwm.c dashboard.c
software components: CMSIS:CORE 6.2.0
